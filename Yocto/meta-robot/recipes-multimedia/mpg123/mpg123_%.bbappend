PACKAGECONFIG:remove = "pulseaudio"
PACKAGECONFIG:append = " alsa"
